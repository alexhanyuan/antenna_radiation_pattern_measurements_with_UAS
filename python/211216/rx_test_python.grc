options:
  parameters:
    gen_cmake: 'Off'
    generate_options: no_gui
    id: rx_test_python
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: averages
  id: parameter
  parameters:
    type: intx
    value: '10'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_samps
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: averages
    max_iter: '4000'
    scale: wav_scaling
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: '''/home/alex/Desktop/hackrf_grc/211216/'' + filename + ''.wav'''
    samp_rate: samp_rate
  states: {}
- name: filename
  id: parameter
  parameters:
    type: str
    value: data_woo_ya
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: intx
    value: '447100000'
  states: {}
- name: num_samps
  id: parameter
  parameters:
    type: intx
    value: '10000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '1000000'
  states: {}
- name: wav_scaling
  id: parameter
  parameters:
    type: eng_float
    value: '0.03'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_head_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_wavfile_sink_0, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
