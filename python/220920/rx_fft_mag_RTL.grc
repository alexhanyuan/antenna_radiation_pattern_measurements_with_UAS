options:
  parameters:
    gen_cmake: 'Off'
    generate_options: no_gui
    id: rx_fft_mag_RTL
    output_language: python
    run_options: run
    title: rx_fft_mag_RTL
  states: {}

blocks:
- name: m
  id: variable
  parameters:
    value: '256'
  states: {}
- name: num_points
  id: variable
  parameters:
    value: '81920'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: num_points
    value: '57392'
  states: {state: disabled}
- name: offset
  id: variable
  parameters:
    value: '57392'
  states: {}
- name: RF_gain
  id: parameter
  parameters:
    type: intx
    value: '10'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_points
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '''./'' + filename + ''.bin'''
    type: float
    vlen: '512'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_points*num_buffers
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: m
    n: num_points
    offset: offset
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: num_points
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_points
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '512'
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_points
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_points
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_points)
  states: {}
- name: filename
  id: parameter
  parameters:
    type: str
    value: data_woo_ya
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: intx
    value: '443000000'
  states: {}
- name: num_buffers
  id: parameter
  parameters:
    type: intx
    value: '10'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"fft"'
    size: num_points
    srate: samp_rate
    type: float
    ymax: '70'
    ymin: '-25'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"keep M in N"'
    size: m
    srate: samp_rate
    type: float
    ymax: '70'
    ymin: '-25'
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency-200000
    gain0: RF_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '1000000'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [rtlsdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
